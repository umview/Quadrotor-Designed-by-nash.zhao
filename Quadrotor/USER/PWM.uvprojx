# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\MPU6050;..\HARDWARE\HMC5883
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c include.h Config.h Config.c Debug.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/: Driver.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/PLOT/: SDS.c DataScope_DP.C
    ../HARDWARE/SDRAM/: SDRAM.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f429_439xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_fmc.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_spi.c
  group README
    ../: readme.txt
  group Control
    ../Control/: Schedule.c Controller.c
  group MPU6050
    ../MPU6050/: imu.c mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c mpu6050_process.c
